<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x5149;&#x7167;&#x4F20;&#x611F;&#x5668;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


