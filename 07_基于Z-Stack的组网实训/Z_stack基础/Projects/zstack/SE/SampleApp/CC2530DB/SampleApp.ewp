# IAR project SampleApp.ewp, settings and files
configuration ESP - Coordinator (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2530.i51
  ICC8051.CCDefines: ZIGBEEPRO; SE_PROFILE; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; LCD_SUPPORTED; INT_HEAP_LEN=2450; NV_INIT; xNV_RESTORE; ZCL_REPORT
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\SOURCE; ..\..\..\ZMAIN\TI2530DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530EB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZCL; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration In Premise Display - End Device (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; SE_PROFILE; NV_INIT; NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; LCD_SUPPORTED; HOLD_AUTO_START; xNV_RESTORE
configuration Load Control Device - Router (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; SE_PROFILE; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; LCD_SUPPORTED; NV_INIT; xNV_RESTORE; INT_HEAP_LEN=2500; HOLD_AUTO_START
configuration PCT - End Device (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; NWK_AUTO_POLL; SE_PROFILE; NV_INIT; xNV_RESTORE; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; LCD_SUPPORTED; INT_HEAP_LEN=2560; xPOWER_SAVING; HOLD_AUTO_START
configuration Range Extender - Router (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; SE_PROFILE; INT_HEAP_LEN=2560; NV_INIT; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; LCD_SUPPORTED; xNV_RESTORE; HOLD_AUTO_START
configuration Simple Metering - End Device (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; SE_PROFILE; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; LCD_SUPPORTED; NV_INIT; xNV_RESTORE; HOLD_AUTO_START; NWK_AUTO_POLL; ZCL_REPORT
configuration Simple Metering - Router (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZIGBEEPRO; SE_PROFILE; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; LCD_SUPPORTED; NV_INIT; xNV_RESTORE; INT_HEAP_LEN=2560; ZCL_REPORT; HOLD_AUTO_START
  group App/ESP
    ../Source/ESP/: esp.c esp.h esp_data.c OSAL_ESP.c
  group App/In Premise Display
    ../Source/IPD/: ipd.c ipd.h ipd_data.c OSAL_ipd.c
  group App/Load Control Device
    ../Source/LoadControl/: loadcontrol.c loadcontrol.h loadcontrol_data.c OSAL_LoadControl.c
  group App/PCT
    ../Source/PCT/: OSAL_pct.c pct.c pct.h pct_data.c
  group App/Range Extender
    ../Source/RangeExt/: OSAL_RangeExt.c rangeext.c rangeext.h rangeext_data.c
  group App/Simple Metering
    ../Source/SimpleMeter/: OSAL_SimpleMeter.c simplemeter.c simplemeter.h simplemeter_data.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../COMPONENTS/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../../Components/hal/include/: hal_ccm.h
  group HAL/Target/CC2530EB/Config
    ../../../../../COMPONENTS/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../COMPONENTS/hal/target/CC2530EB/: hal_aes.h hal_mcu.h hal_types.h
    ../../../../../Components/hal/target/CC2530EB/: hal_dma.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c
    ../../../../../COMPONENTS/mac/HIGH_LEVEL/: mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../COMPONENTS/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../COMPONENTS/mac/LOW_LEVEL/srf04/: mac_assert.h mac_backoff_timer.h mac_low_level.h mac_rx.h mac_rx_onoff.h mac_tx.h
    ../../../../../Components/mac/low_level/srf04/: mac_backoff_timer.c mac_low_level.c mac_radio.c mac_radio.h mac_rx.c mac_rx_onoff.c mac_sleep.c mac_sleep.h mac_tx.c
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/: mac_autopend.c mac_autopend.h
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c mac_radio_defs.h
    ../../../../../COMPONENTS/mac/LOW_LEVEL/srf04/SINGLE_CHIP/: mac_csp_tx.h mac_mcu.h mac_mem.h
  group MT
    ../../../../../Components/mt/: DebugTrace.c MT.c MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_TASK.c MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
    ../../../../../COMPONENTS/mt/: DebugTrace.h MT.h MT_SYS.h MT_TASK.h
  group NWK
    ../../../../../COMPONENTS/stack/nwk/: AddrMgr.h APS.h aps_groups.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.h nwk_util.h reflecttrack.h rtg.h
    ../../../../../Components/stack/nwk/: aps_util.h nwk_globals.c stub_aps.c stub_aps.h
    ../../../../../Components/stack/sys/: ZGlobals.c
    ../../../../../COMPONENTS/stack/sys/: ZGlobals.h
  group OSAL
    ../../../../../COMPONENTS/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Nv.c
  group Profile
    ../../../../../Components/stack/af/: AF.c
    ../../../../../COMPONENTS/stack/af/: AF.h
    ../../Source/: se.c se.h
    ../../../../../Components/stack/zcl/: zcl.c zcl_general.c zcl_key_establish.c zcl_se.c
    ../../../../../COMPONENTS/stack/zcl/: zcl.h zcl_general.h zcl_key_establish.h zcl_se.h
  group Security
    ../../../../../COMPONENTS/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c
    ../../../../../COMPONENTS/services/saddr/: saddr.h
  group Tools
    ../../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDConfig.c ZDNwkMgr.c ZDObject.c ZDObject.h ZDProfile.c ZDSecMgr.c ZDSecMgr.h
    ../../../../../COMPONENTS/stack/zdo/: ZDApp.h ZDConfig.h ZDNwkMgr.h ZDProfile.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c
    ../../../../../COMPONENTS/zmac/: ZMAC.h
    ../../../../../COMPONENTS/zmac/f8w/: zmac_internal.h
  group ZMain
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
