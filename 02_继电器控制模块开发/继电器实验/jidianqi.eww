<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x7ee7;&#x7535;&#x5668;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


