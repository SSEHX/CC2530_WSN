# IAR project Backup of sensor.ewp, settings and files
configuration collect (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils; ..\CC2530_lib\moudle
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2530.xcl
configuration gd_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: GD_SENDOR; xCO_SENDOR; xKRQ_SENDOR; xFIR_SENDOR; xRT_SENDOR; xTEM_SENDOR
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils; ..\CC2530_lib\MyLib; ..\CC2530_lib\moudle; ..\sensor_drv
configuration co_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xGD_SENDOR; CO_SENDOR; xKRQ_SENDOR; xFIR_SENDOR; xRT_SENDOR; xTEM_SENDOR
  ICC8051.CCIncludePath2: as above
configuration krg_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xGD_SENDOR; xCO_SENDOR; KRQ_SENDOR; xFIR_SENDOR; xRT_SENDOR; xTEM_SENDOR
  ICC8051.CCIncludePath2: as above
configuration FIR_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xGD_SENDOR; xCO_SENDOR; xKRQ_SENDOR; FIR_SENDOR; xRT_SENDOR; xTEM_SENDOR
  ICC8051.CCIncludePath2: as above
configuration TEM_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xGD_SENDOR; xCO_SENDOR; xKRQ_SENDOR; xFIR_SENDOR; xRT_SENDOR; TEM_SENDOR
  ICC8051.CCIncludePath2: as above
configuration RT_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xGD_SENDOR; xCO_SENDOR; xKRQ_SENDOR; xFIR_SENDOR; RT_SENDOR; xTEM_SENDOR
  ICC8051.CCIncludePath2: as above
configuration Relay (8051, debug)
  as the first configuration, except:
  group app
    ./: collect.c Relay.c sensor.c
  group basicrf
    ../CC2530_lib/basicrf/: basic_rf.r51
  group board
    ../CC2530_lib/board/: hal_board.c hal_led.c
  group common
    ../CC2530_lib/common/: hal_clock.c hal_digio.c hal_int.c hal_mcu.c hal_rf.c hal_rf_security.c hal_uart.c
  group MyLib
    ../CC2530_lib/mylib/: TIMER.c UART_PRINT.c
  group sensor_drv
    ../sensor_drv/: get_adc.c get_swsensor.c sh10.c
  group utils
    ../CC2530_lib/utils/: util.c
