<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x4eBA;&#x4F53;&#x7eA2;&#x5916;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


