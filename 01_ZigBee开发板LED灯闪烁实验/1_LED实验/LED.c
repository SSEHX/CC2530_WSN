/*******************************************************************************
 * 文件名称：LEDTest.c
 * 功    能：CC2530基础实验 --- 点亮LED实验
 *           
 * 硬件连接：led灯端口：p1.0, p1.1, p1.3, p1.4：
 * 
 * 作    者：
 
 ******************************************************************************/
/* 包含头文件 */
/********************************************************************/
#include "ioCC2530.h"  // 引用头文件
/********************************************************************/
//定义led灯端口：p1.0, p1.1, p1.3, p1.4：
#define LED1 P1_0

/*********************************************************************
 * 函数名称：delay
 * 功    能：软件延时
 * 入口参数：unsigned int time：延时时间
 * 出口参数：无
 * 返 回 值：无
 ********************************************************************/
void delay(unsigned int time)
{
  unsigned int i;
  unsigned char j;
  
  for(i = 0; i < time; i++)
  {
    for(j = 0; j < 240; j++)
    {
      asm("NOP");
      asm("NOP");
      asm("NOP");
    }  
  }  
}


/*********************************************************************
 * 函数名称：main
 * 功    能：main函数入口
 * 入口参数：无
 * 出口参数：无
 * 返 回 值：无
 ********************************************************************/
void main(void)
{
  P1SEL &= ~(0x01 );  // 设置P1.0为普通IO口
  P1DIR |= 0x01;     // 设置为输出                              
  while(1)
  {
    LED1 =0; 
    delay(20000); 
    LED1 =1;
    delay(20000);
  }  
}
